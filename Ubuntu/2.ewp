# IAR project 2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 NXP KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: D:\FNXP\2\drives; D:\FNXP\2\drives\inc; D:\FNXP\2\drives\src; D:\FNXP\2; D:\FNXP\2\startup\CoreSupport; D:\FNXP\2\startup\DeviceSupport\IAR-ARM; D:\FNXP\2\startup; D:\FNXP\2\USER
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 2.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\FNXP\2\PROJECT\src\config files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group DRIVERS/INC
    drives/inc/: common.h KEA128_adc.h KEA128_flash.h KEA128_ftm.h KEA128_gpio.h KEA128_i2c.h KEA128_irq.h KEA128_kbi.h KEA128_pit.h KEA128_port.h KEA128_port_cfg.h KEA128_spi.h KEA128_systick.h KEA128_uart.h misc.h
    USER/: LVBO.h pid.h
  group DRIVERS/SRC
    drives/src/: common.c KEA128_adc.c KEA128_flash.c KEA128_ftm.c KEA128_gpio.c KEA128_i2c.c KEA128_irq.c KEA128_kbi.c KEA128_pit.c KEA128_port.c KEA128_spi.c KEA128_systick.c KEA128_uart.c misc.c
    USER/: llvbo.c pid.c
  group SEEKFREE
    USER/: SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_OLED.c SEEKFREE_OLED.h
  group STARTUP
    startup/CoreSupport/: core_cm0plus.h core_cmFunc.h core_cmInstr.h
    startup/: SKEAZ1284.h system_SKEAZ1284.c system_SKEAZ1284.h
    startup/DeviceSupport/IAR-ARM/: startup_SKEAZ1284.s
  group USER_C
    USER/: isr.c isr.h main.c
  group USER_H
    drives/inc/: headfile.h
