# IAR project LQ_KEAZ128demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 Freescale KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: IAR; TRK_KEA128; CPU_KEA128
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; src\common; src\cpu; src\drivers; src\user; ..\; D:\FNXP\龙湫科技\OLED版本\LQ_KEA_OLED版本\3.龙邱提供的测试例程\LQ_KEAZ128_MDK_demo第三版20171205\cpu
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: src\config files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: KEAZ128xxx4 NXP KEAZ128xxx4
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; src\common; src\cpu; src\drivers; src\user; ..\
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: LQ.hex
  ILINK.IlinkOutputFile: LQ.out
  group common
    src/common/: assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.h typedef.h
  group cpu
    src/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.c sysinit.h system_SKEAZ1284.h systick.c systick.h vectors.c vectors.h
  group drivers
    src/drivers/: acmp.h adc.c adc.h bitband.h BME.h crc.c crc.h flash.c flash.h ftm.c ftm.h gpio.c gpio.h gpio_icf.h i2c.c i2c.h ics.c ics.h kbi.c kbi.h mscan.c mscan.h pit.c pit.h pmc.c pmc.h pwt.c pwt.h rtc.c rtc.h sim.c sim.h spi.c spi.h uart.c uart.h wdog.c wdog.h
    src/user/: kea128_config.h SKEAZ1284.h
  group user
    src/user/: 8700_2100.c 8700_2100.h include.h isr.c isr.h LQ12864.c LQ12864.h LQKEY.c LQKEY.h LQLED.c LQLED.h main.c MPU6050.c MPU6050.h MPUIIC.c MPUIIC.h Serial_oscilloscope.c Serial_oscilloscope.h
